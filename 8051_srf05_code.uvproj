# Keil uVision project 8051_srf05_code.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 8051_srf05_code +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LIB_lcd_8051.c LIB_lcd_8051.h Port_lcd_4bit.h
